# IAR project GUI_Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MATCO_TOOLS=1
  ICCARM.PreInclude: ..\1_Application\1_Tool_Configuration\OBDToolConf.h
  ICCARM.CCIncludePath2: ..\; ..\0_Common_Use\; ..\1_Application\; ..\1_Application\1_Tool_Configuration\; ..\1_Application\2_System_Initialization\; ..\1_Application\3_User_Interface\; ..\1_Application\3_User_Interface\2_GUI_Database; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\1_Text_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\Mis; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\MonitorIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\StatusIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\TextIcon; ..\1_Application\3_User_Interface\3_UI_Processes\; ..\1_Application\3_User_Interface\3_UI_Processes\Proc_Mangager\; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\04_YMME_Selection; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\11_Communication; ..\1_Application\3_User_Interface\4_Key_Processes\; ..\1_Application\3_User_Interface\6_UI_Uilities\; ..\2_Middle; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\System_Process_UI; ..\2_Middle\1_Display\1_LED\; ..\2_Middle\1_Display\2_LCM\1_App_API\Font\; ..\2_Middle\1_Display\2_LCM\1_App_API\Innova_GUI\inc\; ..\2_Middle\1_Display\2_LCM\2_Driver\; ..\2_Middle\1_Display\2_LCM\3_App_Driver_Interface\; ..\2_Middle\2_Vehicle_Interface\; ..\2_Middle\3_Storage\1_App_API\; ..\2_Middle\3_Storage\2_Driver\; ..\2_Middle\3_Storage\2_Driver\0_FAT_Driver\FatFs\; ..\2_Middle\3_Storage\2_Driver\1_Internal_Flash; ..\2_Middle\3_Storage\2_Driver\2_External_Flash; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\1_App_API\; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\2_Driver\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\1_App_API\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\2_Driver\; ..\2_Middle\3_Storage\2_Driver\5_eMMC; ..\2_Middle\4_User_Input\1_Keypad\; ..\2_Middle\5_Communication\1_Usb\; ..\2_Middle\5_Communication\1_Usb\1_App_API\; ..\2_Middle\5_Communication\1_Usb\2_Core\Libraries\; ..\2_Middle\5_Communication\1_Usb\2_Core\usr\; ..\2_Middle\5_Communication\2_Bluetooth\; ..\2_Middle\6_Sound\1_Buzzer\; ..\2_Middle\8_System\; ..\2_Middle\8_System\Cable_ID; ..\2_Middle\8_System\SPI\; ..\2_Middle\8_System\Timer\; ..\2_Middle\8_System\Power\; ..\3_Hardware_Core\; ..\3_Hardware_Core\1_MCU_Core\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\startup\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\CMSIS\Include; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\peripheral\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GUI_Lib.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group 1_Application_API/Font
    ../2_Middle/1_Display/2_LCM/1_App_API/Font/: Font.h OBD31x0D_Font _21height.c
  group 1_Application_API/Innova_GUI
    ../2_Middle/1_Display/2_LCM/1_App_API/Innova_GUI/src/: GUIManager.c
  group 1_Application_API/Innova_GUI/App
    ../2_Middle/1_Display/2_LCM/1_App_API/Innova_GUI/src/: GuiDigitSelectionForm.c GuiDTCForm.c GuiFlashScrnForm.c GuiGraph.c GuiHighlightTextForm.c GuiIcons.c GuiImage_InternalFlash.c GuiInfoImageForm.c GuiInfoValueList.c GuiMenuForm.c GuiMenuForm_New.c GuiProgressBarForm.c GuiTextForm.c
  group 1_Application_API/Innova_GUI/Core
    ../2_Middle/1_Display/2_LCM/1_App_API/Innova_GUI/src/: GuiCore.c GuiDraw.c GuiLcdDriver.c GuiList.c GuiString.c GuiWindow.c
  group 2_Driver
    ../2_Middle/1_Display/2_LCM/2_Driver/: FSMC_LCD_Driver.c HX8347Driver.c UC1611Driver.c
  group 3_Interface
    ../2_Middle/1_Display/2_LCM/3_App_Driver_Interface/: GUIApp_Driver_Interface.c GUIApp_Driver_Interface.h GUIApp_Driver_Interface_Macro.h
