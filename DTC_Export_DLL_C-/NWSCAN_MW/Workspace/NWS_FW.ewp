# IAR project NWS_FW.ewp, settings and files
configuration UI_Lib_Nand (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427ZI ST STM32F427ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: MATCO_TOOLS=1; DEBUG_ENABLE_MASS_STORAGE=1; FLASH_SECURE_DISABLE; SCROLL_UP_DOWN_DTC; USING_NAND_FLASH=1; NAND_USE_ADC_3_INTERRUPT=1; _INFLASH_VEHICLE_DATA
  ICCARM.PreInclude: ..\1_Application\1_Tool_Configuration\OBDToolConf.h
  ICCARM.CCIncludePath2: ..\; ..\0_Common_Use\; ..\1_Application\; ..\1_Application\1_Tool_Configuration\; ..\1_Application\2_System_Initialization\; ..\1_Application\3_User_Interface\; ..\1_Application\3_User_Interface\2_GUI_Database; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\1_Text_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\DLC_Locator; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\Mis; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\MonitorIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\StatusIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\TextIcon; ..\1_Application\3_User_Interface\3_UI_Processes\; ..\1_Application\3_User_Interface\3_UI_Processes\Proc_Mangager\; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\04_YMME_Selection; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\11_Communication; ..\1_Application\3_User_Interface\4_Key_Processes\; ..\1_Application\3_User_Interface\6_UI_Uilities\; ..\2_Middle; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\System_Process_UI; ..\2_Middle\1_Display\1_LED\; ..\2_Middle\1_Display\2_LCM\1_App_API\Font\; ..\2_Middle\1_Display\2_LCM\1_App_API\Innova_GUI\inc\; ..\2_Middle\1_Display\2_LCM\2_Driver\; ..\2_Middle\1_Display\2_LCM\3_App_Driver_Interface\; ..\2_Middle\2_Vehicle_Interface\; ..\2_Middle\2_Vehicle_Interface\1_OBD_API\NWSCAN_APP\; ..\2_Middle\3_Storage\1_App_API\; ..\2_Middle\3_Storage\2_Driver\; ..\2_Middle\3_Storage\2_Driver\0_FAT_Driver\FatFs\; ..\2_Middle\3_Storage\2_Driver\1_Internal_Flash; ..\2_Middle\3_Storage\2_Driver\2_External_Flash; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\1_App_API\; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\2_Driver\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\1_App_API\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\2_Driver\; ..\2_Middle\3_Storage\2_Driver\5_eMMC; ..\2_Middle\4_User_Input\1_Keypad\; ..\2_Middle\5_Communication\1_Usb\; ..\2_Middle\5_Communication\1_Usb\1_App_API\; ..\2_Middle\5_Communication\1_Usb\2_Core\Libraries\; ..\2_Middle\5_Communication\1_Usb\2_Core\usr\; ..\2_Middle\5_Communication\2_Bluetooth\; ..\2_Middle\6_Sound\1_Buzzer\; ..\2_Middle\8_System\; ..\2_Middle\8_System\Cable_ID; ..\2_Middle\8_System\SPI\; ..\2_Middle\8_System\Timer\; ..\2_Middle\8_System\Power\; ..\3_Hardware_Core\; ..\3_Hardware_Core\1_MCU_Core\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\startup\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\CMSIS\Include; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\peripheral\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $CONFIG_NAME$.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: ..\3_Hardware_Core\1_MCU_Core\STM32F427x\startup\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../1_Application/: OBDToolMain.c
  group 0_Common_Use
    ../0_Common_Use/: hamming.c math_Atmel.c PlatformType.h
  group 1_Application/1_Tool_Configuration
    ../1_Application/1_Tool_Configuration/: MD75_85_Conf.c MD75_85_Conf.h OBD31x0E_Conf.c OBD31x0E_Conf.h OBDToolConf.h
  group 1_Application/2_System_Initialization
    ../1_Application/2_System_Initialization/: OBDToolSetting.c OBDToolSetting.h SystemDriver.c SystemDriver.h
  group 1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/1_Text_DB
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/1_Text_DB/: Common_Text_Database.c Common_Text_Database.h
  group 1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/: InnovaLogo.c
  group 1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/DLC_Locator
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/DLC_Locator/: Innova_DLC_PoLap Dangions01.c Innova_DLC_PoLap Dangions01_atv.c Innova_DLC_PoLap Dangions02.c Innova_DLC_PoLap Dangions02_atv.c Innova_DLC_PoLap Dangions03.c Innova_DLC_PoLap Dangions03_atv.c Innova_DLC_PoLap Dangions04.c Innova_DLC_PoLap Dangions04_atv.c Innova_DLC_PoLap Dangions05.c Innova_DLC_PoLap Dangions05_atv.c Innova_DLC_PoLap Dangions06.c Innova_DLC_PoLap Dangions06_atv.c Innova_DLC_PoLap Dangions07.c Innova_DLC_PoLap Dangions07_atv.c Innova_DLC_PoLap Dangions08.c Innova_DLC_PoLap Dangions08_atv.c Innova_DLC_PoLap Dangions09.c Innova_DLC_PoLap Dangions09_atv.c Innova_DLCPosInit.c
  group 1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/Mis
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/Mis/: down.c dtc.c enter.c erase.c InnovaCheckIcon.c InnovaLedGreen.c InnovaLedRed.c InnovaLedYellow.c LD.c link.c M.c power.c systems.c up.c
  group 1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/MonitorIcon
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/MonitorIcon/: InnovaAIR.c InnovaAIR_RED.c InnovaBPS.c InnovaBPS_RED.c InnovaCAT.c InnovaCAT_RED.c InnovaCCM.c InnovaCCM_RED.c InnovaDPF.c InnovaDPF_RED.c InnovaEGR.c InnovaEGR_RED.c InnovaEGS.c InnovaEGS_RED.c InnovaEVA.c InnovaEVA_RED.c InnovaFUE.c InnovaFUE_RED.c InnovaHCA.c InnovaHCA_RED.c InnovaHCC.c InnovaHCC_RED.c InnovaHTR.c InnovaHTR_RED.c InnovaMIS.c InnovaMIS_RED.c InnovaNOx.c InnovaNOx_RED.c InnovaO2S.c InnovaO2S_RED.c
  group 1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/StatusIcon
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/StatusIcon/: InnovaABS.c InnovaBattery.c InnovaComputer.c InnovaHorBattery.c InnovaHorComputer.c InnovaHorLink.c InnovaHorMIL.c InnovaHorVehicle.c InnovaLink.c InnovaMIL.c InnovaSRS.c InnovaVehicle.c
  group 1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/TextIcon
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/2_Image_DB/TextIcon/: InnovaFF.c InnovaIM.c
  group 1_Application/3_User_Interface/3_UI_Processes/Proc_Manager
    ../1_Application/3_User_Interface/3_UI_Processes/Proc_Mangager/: OBDToolManager.c OBDToolManager.h Processes.c Processes.h
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/00_Tool_Init
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/00_Tool_Init/: Proc_ToolInit.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/01_Tool_Setting
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/01_Tool_Setting/: Proc_AdjustBrightness.c Proc_AudibleTone.c Proc_FooterSetting.c Proc_HotkeyLegends.c Proc_SelectLanguage.c Proc_SelectUnit.c Proc_SetupMenu.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/02_Tool_Library
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/02_Tool_Library/: Proc_Glossary.c Proc_LedMeaning.c Proc_MonitorIcon.c Proc_ToolLibrary.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/03_Tool_Version_Info
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/03_Tool_Version_Info/: Proc_FirmwareVersion.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection/: Proc_YMMESelection.c YMME_Structure.h
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection/Lib
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection/: YMMESelection.h YMMESelection_V01.00.xx_2014.a
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/05_VIN_Decode
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/05_VIN_Decode/: VinDecode.h VINDecode_V01.00.02_Jan092015.a
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/08_DLC_Locator
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/08_DLC_Locator/: DLC_Locator_V01.00.xx_Date.a DLCLocator.h DLCLocatorEnumeration.h Proc_DLC_Locator.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/11_Communication
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/11_Communication/: Proc_USB.c USBInterface.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/Other_Processes
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/Other_Processes/: Proc_MainMenu.c
  group 1_Application/3_User_Interface/4_Key_Processes
    ../1_Application/3_User_Interface/4_Key_Processes/: CommonKeyHandler.c CommonKeyHandler.h
  group 1_Application/3_User_Interface/5_Vehicle_Data_Process
    ../1_Application/3_User_Interface/5_Vehicle_Data_Process/: Vehicle_Data_Manager.c Vehicle_Data_Manager.h Vehicle_Data_Structure.h
  group 1_Application/3_User_Interface/6_UI_Utilites
    ../1_Application/3_User_Interface/6_UI_Uilities/: Common_LCD_Screen.c Common_LCD_Screen.h
  group 2_Middle/0_Middle_Utilities
    ../2_Middle/0_Middle_Utilities/: ByteStringUtilities.c ByteStringUtilities.h InnovaCommonEnum.h MLStringUtilities.c MLStringUtilities.h SystemModeFunctionUtilities.c SystemModeFunctionUtilities.h
  group 2_Middle/0_Middle_Utilities/AES
    ../2_Middle/0_Middle_Utilities/AES/: aes256.h Pro_ASE_Sep232014_V01.00.00.a
  group 2_Middle/0_Middle_Utilities/System_Process_UI
    ../2_Middle/0_Middle_Utilities/System_Process_UI/: SysProcess.c SysProcess.h
  group 2_Middle/1_Display/1_LED
    ../2_Middle/1_Display/1_LED/: LedDriver.c LedDriver.h
  group 2_Middle/1_Display/2_LCM/Lib
    ../2_Middle/1_Display/2_LCM/: GUI_Lib.a
  group 2_Middle/1_Display/2_LCM/Source/1_Application_API/Font
    ../2_Middle/1_Display/2_LCM/1_App_API/Font/: Font.h OBD31x0D_Font _21height.c
  group 2_Middle/1_Display/2_LCM/Source/1_Application_API/Innova_GUI
    ../2_Middle/1_Display/2_LCM/1_App_API/Innova_GUI/src/: GUIManager.c
  group 2_Middle/1_Display/2_LCM/Source/1_Application_API/Innova_GUI/App
    ../2_Middle/1_Display/2_LCM/1_App_API/Innova_GUI/src/: GuiDigitSelectionForm.c GuiDTCForm.c GuiFlashScrnForm.c GuiGraph.c GuiHighlightTextForm.c GuiIcons.c GuiImage_InternalFlash.c GuiInfoImageForm.c GuiInfoValueList.c GuiMenuForm.c GuiMenuForm_New.c GuiProgressBarForm.c GuiTextForm.c INN_GuiInfoValueForm.c INN_GuiMenuForm.c INN_GuiTextForm.c INNGuiDLCLocatorForm.c INNGuiInputTextForm.c INNGuiTextForm.c INNGuiTextResult.c
  group 2_Middle/1_Display/2_LCM/Source/1_Application_API/Innova_GUI/Core
    ../2_Middle/1_Display/2_LCM/1_App_API/Innova_GUI/src/: GuiCore.c GuiDraw.c GuiLcdDriver.c GuiList.c GuiString.c GuiWindow.c
  group 2_Middle/1_Display/2_LCM/Source/2_Driver
    ../2_Middle/1_Display/2_LCM/2_Driver/: FSMC_LCD_Driver.c GoldentekDriver.c HX8347Driver.c UC1611Driver.c
  group 2_Middle/1_Display/2_LCM/Source/3_Interface
    ../2_Middle/1_Display/2_LCM/3_App_Driver_Interface/: GUIApp_Driver_Interface.c GUIApp_Driver_Interface.h GUIApp_Driver_Interface_Macro.h
  group 2_Middle/2_Vehicle_Interface/1_OBD_API
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/LIB/: DTCDefinition.c DtcParser.h InnovaOBDApp.h InnovaStd.h NWSCAN_3130E_LIB_V1.0.16.a NWSCAN_MW_LIB_V1.0.8.a OBDIISidUtility.h SYS_Utility.h VBI_Default_App.h VBI_Utility.h VCI_App.h VDM_Adapter.h
  group 2_Middle/3_Storage/1_App_API
    ../2_Middle/3_Storage/1_App_API/: MemoryInterfaceInternalFlash.c MemoryInterfaceInternalFlash.h StorageMemoryInterface.c
  group 2_Middle/3_Storage/2_Driver/0_FAT_Driver
    ../2_Middle/3_Storage/2_Driver/0_FAT_Driver/FatFs/src/option/: ccsbcs.c
    ../2_Middle/3_Storage/2_Driver/0_FAT_Driver/FatFs/src/: diskio_nand.c diskio_sd.c fattime.c ff.c
  group 2_Middle/3_Storage/2_Driver/1_Internal_Flash
    ../2_Middle/3_Storage/2_Driver/1_Internal_Flash/: intflashdriver.h STM32F4xxIntFlashDriver.c
  group 2_Middle/3_Storage/2_Driver/2_External_Flash
    ../2_Middle/3_Storage/2_Driver/2_External_Flash/: ExFlashDriver.c ExFlashInterface.c
  group 2_Middle/3_Storage/2_Driver/3_Nand_Flash/1_App_API
    ../2_Middle/3_Storage/2_Driver/3_Nand_Flash/1_App_API/: nandfs.c nandfs.h
  group 2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver
    ../2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver/: fsmc_nand.c
  group 2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver/Media
    ../2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver/Media/: Media.c MEDNandFlash.c
  group 2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver/mFTL
    ../2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver/mFTL/: m69aLLD.c mmlib_CortexM4.a
  group 2_Middle/3_Storage/2_Driver/4_SD_Card/1_App_API
    ../2_Middle/3_Storage/2_Driver/4_SD_Card/1_App_API/: SDCardApp.c SDCardApp.h
  group 2_Middle/3_Storage/2_Driver/4_SD_Card/2_Driver
    ../2_Middle/3_Storage/2_Driver/4_SD_Card/2_Driver/: sdcard.c SDCard.h
  group 2_Middle/4_User_Input/1_Keypad
    ../2_Middle/4_User_Input/1_Keypad/: ButtonDriver.c GuiKey.c KeyBoardApp.c
  group 2_Middle/5_Communication/1_Usb/2_Core/Libraries/Device_Library/Core
    ../2_Middle/5_Communication/1_Usb/2_Core/Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c
  group 2_Middle/5_Communication/1_Usb/2_Core/Libraries/Device_Library/hid
    ../2_Middle/5_Communication/1_Usb/2_Core/Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
  group 2_Middle/5_Communication/1_Usb/2_Core/Libraries/Device_Library/msc
    ../2_Middle/5_Communication/1_Usb/2_Core/Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group 2_Middle/5_Communication/1_Usb/2_Core/Libraries/OTG_Driver
    ../2_Middle/5_Communication/1_Usb/2_Core/Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group 2_Middle/5_Communication/1_Usb/2_Core/usr
    ../2_Middle/5_Communication/1_Usb/2_Core/usr/: usb_bsp.c usbd_storage_msd.c usbd_usr.c
  group 2_Middle/6_Sound/1_Buzzer
    ../2_Middle/6_Sound/1_Buzzer/: BuzzerDriver.c
  group 2_Middle/8_System/Cable_ID
    ../2_Middle/8_System/Cable_ID/: Cable_ID.c Cable_ID.h
  group 2_Middle/8_System/Power
    ../2_Middle/8_System/Power/: PowerDriver.c PowerDriver.h
  group 2_Middle/8_System/SPI
    ../2_Middle/8_System/SPI/: SPIDriver.c SPIDriver.h
  group 2_Middle/8_System/Timer
    ../2_Middle/8_System/Timer/: TimerApp.c TimerApp.h TimerDriver.c TimerDriver.h
  group 3_Hardware_Core/1_MCU_Core
    ../3_Hardware_Core/1_MCU_Core/: coremcu.h
  group 3_Hardware_Core/1_MCU_Core/STM32F427x/Peripheral
    ../3_Hardware_Core/1_MCU_Core/STM32F427x/peripheral/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group 3_Hardware_Core/1_MCU_Core/STM32F427x/StartUp
    ../3_Hardware_Core/1_MCU_Core/STM32F427x/startup/: startup_stm32f4xx.s stm32f4xx_flash.icf stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
  group 5_UI_Lib
    ../1_Application/5_UI_Lib/: UI_Lib_Nand_Date.a
