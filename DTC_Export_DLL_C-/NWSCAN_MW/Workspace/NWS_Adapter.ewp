# IAR project NWS_Adapter.ewp, settings and files
configuration DTC_ADAPTER_LIB (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427ZI ST STM32F427ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MATCO_TOOLS=1; DEBUG_ENABLE_MASS_STORAGE=1; FLASH_SECURE_DISABLE; SCROLL_UP_DOWN_DTC; USING_NAND_FLASH=1; NAND_USE_ADC_3_INTERRUPT=1; _INFLASH_VEHICLE_DATA
  ICCARM.CCDiagSuppress: pe167,pe174,pa039,pe188
  ICCARM.PreInclude: ..\1_Application\1_Tool_Configuration\OBDToolConf.h
  ICCARM.CCIncludePath2: ..\; ..\0_Common_Use\; ..\1_Application\; ..\1_Application\1_Tool_Configuration\; ..\1_Application\2_System_Initialization\; ..\1_Application\3_User_Interface\; ..\1_Application\3_User_Interface\2_GUI_Database; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\1_Text_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\DLC_Locator; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\Mis; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\MonitorIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\StatusIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\TextIcon; ..\1_Application\3_User_Interface\3_UI_Processes\; ..\1_Application\3_User_Interface\3_UI_Processes\Proc_Mangager\; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\04_YMME_Selection; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\11_Communication; ..\1_Application\3_User_Interface\4_Key_Processes\; ..\1_Application\3_User_Interface\6_UI_Uilities\; ..\2_Middle; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\System_Process_UI; ..\2_Middle\1_Display\1_LED\; ..\2_Middle\1_Display\2_LCM\1_App_API\Font\; ..\2_Middle\1_Display\2_LCM\1_App_API\Innova_GUI\inc\; ..\2_Middle\1_Display\2_LCM\2_Driver\; ..\2_Middle\1_Display\2_LCM\3_App_Driver_Interface\; ..\2_Middle\2_Vehicle_Interface\; ..\2_Middle\2_Vehicle_Interface\1_OBD_API\; ..\2_Middle\2_Vehicle_Interface\1_OBD_API\NWSCAN_APP\; ..\2_Middle\2_Vehicle_Interface\1_OBD_API\NWSCAN_APP\LIB\; ..\2_Middle\2_Vehicle_Interface\1_OBD_API\NWSCAN_APP\MW_LIB\; ..\2_Middle\3_Storage\1_App_API\; ..\2_Middle\3_Storage\2_Driver\; ..\2_Middle\3_Storage\2_Driver\0_FAT_Driver\FatFs\; ..\2_Middle\3_Storage\2_Driver\1_Internal_Flash; ..\2_Middle\3_Storage\2_Driver\2_External_Flash; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\1_App_API\; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\2_Driver\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\1_App_API\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\2_Driver\; ..\2_Middle\3_Storage\2_Driver\5_eMMC; ..\2_Middle\4_User_Input\1_Keypad\; ..\2_Middle\5_Communication\1_Usb\; ..\2_Middle\5_Communication\1_Usb\1_App_API\; ..\2_Middle\5_Communication\1_Usb\2_Core\Libraries\; ..\2_Middle\5_Communication\1_Usb\2_Core\usr\; ..\2_Middle\5_Communication\2_Bluetooth\; ..\2_Middle\6_Sound\1_Buzzer\; ..\2_Middle\8_System\; ..\2_Middle\8_System\Cable_ID; ..\2_Middle\8_System\SPI\; ..\2_Middle\8_System\Timer\; ..\2_Middle\8_System\Power\; ..\3_Hardware_Core\; ..\3_Hardware_Core\1_MCU_Core\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\startup\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\CMSIS\Include; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\peripheral\inc; ..\..\Release; ..\..\Release\NWSCAN_APP\; ..\..\Release\NWSCAN_APP\LIB; ..\..\Release\NWSCAN_APP\MW_LIB; ..\..\Release\PROTOCOL_LIB; ..\..\Release\MWSCAN_LIB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $CONFIG_NAME$.bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: ..\3_Hardware_Core\1_MCU_Core\STM32F427x\startup\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group 2_Middle/2_Vehicle_Interface/LIB
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/LIB/: DtcParser.h InnovaOBDApp.h InnovaStd.h OBDIISidUtility.h PlatFormType.h SYS_Utility.h VBI_Default_App.h VBI_Utility.h VCI_App.h VCI_OBD1_App.h VDM_Adapter.h
  group 2_Middle/2_Vehicle_Interface/MW_APP/Source/DTC
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/DTC/: BMW_Adapter_DtcDef.c CHRYSLER_Adapter_DtcDef.c Default_Adapter_DtcDef.c DTCDefinition.c DTCDefinition.h DTCDefinitionConfig.h DTCUtilities.c FIAT_Adapter_DtcDef.c FORD_Adapter_DtcDef.c GLOBAL_TRUCK_Adapter_DtcDef.c GM_Adapter_DtcDef.c HONDA_Adapter_DtcDef.c HUYNDAI_Adapter_DtcDef.c JAGUAR_LAND_ROVER_Adapter_DtcDef.c MAZDA_Adapter_DtcDef.c MERCEDES_BENZ_Adapter_DtcDef.c MITSUBISHI_Adapter_DtcDef.c NISSAN_Adapter_DtcDef.c RENAULT_Adapter_DtcDef.c SUBARU_Adapter_DtcDef.c SUZUKI_Adapter_DtcDef.c TOYOTA_Adapter_DtcDef.c VDM_DTC_Path.c VOLKSWAGEN_Adapter_DtcDef.c VOLVO_Adapter_DtcDef.c
