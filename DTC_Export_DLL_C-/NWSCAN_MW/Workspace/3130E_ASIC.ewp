# IAR project 3130E_ASIC.ewp, settings and files
configuration UI_Lib_Nand (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427ZI ST STM32F427ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: MATCO_TOOLS=1; DEBUG_ENABLE_MASS_STORAGE=1; FLASH_SECURE_DISABLE; SCROLL_UP_DOWN_DTC; USING_NAND_FLASH=1; NAND_USE_ADC_3_INTERRUPT=1; _INFLASH_VEHICLE_DATA
  ICCARM.PreInclude: ..\1_Application\1_Tool_Configuration\OBDToolConf.h
  ICCARM.CCIncludePath2: ..\; ..\0_Common_Use\; ..\1_Application\; ..\1_Application\1_Tool_Configuration\; ..\1_Application\2_System_Initialization\; ..\1_Application\3_User_Interface\; ..\1_Application\3_User_Interface\2_GUI_Database; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\1_Text_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\DLC_Locator; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\Mis; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\MonitorIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\StatusIcon; ..\1_Application\3_User_Interface\2_GUI_Database\1_Main_Flow\2_Image_DB\TextIcon; ..\1_Application\3_User_Interface\3_UI_Processes\; ..\1_Application\3_User_Interface\3_UI_Processes\Proc_Mangager\; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\04_YMME_Selection; ..\1_Application\3_User_Interface\3_UI_Processes\Processes\11_Communication; ..\1_Application\3_User_Interface\4_Key_Processes\; ..\1_Application\3_User_Interface\6_UI_Uilities\; ..\2_Middle; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\; ..\2_Middle\0_Middle_Utilities\System_Process_UI; ..\2_Middle\1_Display\1_LED\; ..\2_Middle\1_Display\2_LCM\1_App_API\Font\; ..\2_Middle\1_Display\2_LCM\1_App_API\Innova_GUI\inc\; ..\2_Middle\1_Display\2_LCM\2_Driver\; ..\2_Middle\1_Display\2_LCM\3_App_Driver_Interface\; ..\2_Middle\2_Vehicle_Interface\; ..\2_Middle\2_Vehicle_Interface\1_OBD_API; ..\2_Middle\2_Vehicle_Interface\1_OBD_API\NWSCAN_APP\; ..\2_Middle\3_Storage\1_App_API\; ..\2_Middle\3_Storage\2_Driver\; ..\2_Middle\3_Storage\2_Driver\0_FAT_Driver\FatFs\; ..\2_Middle\3_Storage\2_Driver\1_Internal_Flash; ..\2_Middle\3_Storage\2_Driver\2_External_Flash; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\1_App_API\; ..\2_Middle\3_Storage\2_Driver\3_Nand_Flash\2_Driver\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\1_App_API\; ..\2_Middle\3_Storage\2_Driver\4_SD_Card\2_Driver\; ..\2_Middle\3_Storage\2_Driver\5_eMMC; ..\2_Middle\4_User_Input\1_Keypad\; ..\2_Middle\5_Communication\1_Usb\; ..\2_Middle\5_Communication\1_Usb\1_App_API\; ..\2_Middle\5_Communication\1_Usb\2_Core\Libraries\; ..\2_Middle\5_Communication\1_Usb\2_Core\usr\; ..\2_Middle\5_Communication\2_Bluetooth\; ..\2_Middle\6_Sound\1_Buzzer\; ..\2_Middle\8_System\; ..\2_Middle\8_System\Cable_ID; ..\2_Middle\8_System\SPI\; ..\2_Middle\8_System\Timer\; ..\2_Middle\8_System\Power\; ..\3_Hardware_Core\; ..\3_Hardware_Core\1_MCU_Core\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\startup\; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\CMSIS\Include; ..\3_Hardware_Core\1_MCU_Core\STM32F427x\peripheral\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $CONFIG_NAME$.bin
  prebuild: cmd /c "d:\Master_Project\OBDTool\Protool\ProtocolApi\branches\FW\UI_NWSCAN\2_Middle\2_Vehicle_Interface\1_OBD_API\NWSCAN_APP\Scripts\Prebuild.bat"
  postbuild: cmd /c "d:\Master_Project\OBDTool\Protool\ProtocolApi\branches\FW\UI_NWSCAN\2_Middle\2_Vehicle_Interface\1_OBD_API\NWSCAN_APP\Scripts\Deploy.bat"
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: ..\3_Hardware_Core\1_MCU_Core\STM32F427x\startup\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration UI_LIB_SD_ASIC (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: MATCO_TOOLS=1; DEBUG_ENABLE_MASS_STORAGE=1; FLASH_SECURE_DISABLE; SCROLL_UP_DOWN_DTC; USING_SD_CARD; USB_MSC_FIRMWARE; _INFLASH_VEHICLE_DATA; ENABLE_LOG_DATA_ERROR=1
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$_V1.0.8.bin
  group (top)
    ../1_APPLICATION/: OBDToolMain.c
  group 0_Common_Use
    ../0_Common_Use/: hamming.c math_Atmel.c PlatformType.h
  group 1_Application/3_User_Interface/3_UI_Processes
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/09_Battery_Reset/: Battery_Reset.a
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/08_DLC_Locator/: DLC_Locator_V01.00.xx_Feb0315.a
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/12_OBD2_Process/: PossibleCause_M4_V01.00.09_Feb042015.a
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection/: Proc_OBD1_GM.c YMMESelection.a YMMESelectionOBD1.a
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/05_VIN_Decode/: VINDecode.a
  group 1_Application/3_User_Interface/3_UI_Processes/Proc_Manager
    ../1_Application/3_User_Interface/3_UI_Processes/Proc_Mangager/: OBDToolManager.h Processes.h
    ../1_APPLICATION/3_USER_INTERFACE/3_UI_PROCESSES/PROC_MANGAGER/: Processes.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/00_Tool_Init
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/00_Tool_Init/: Proc_ToolInit.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection/: Proc_Make_Selection.c Proc_YMMESelection.c YMME_Structure.h
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection/Lib
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/04_YMME_Selection/: YMMESelection.h
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/05_VIN_Decode
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/05_VIN_Decode/: VinDecode.h
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/08_DLC_Locator
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/08_DLC_Locator/: DLCLocator.h DLCLocatorEnumeration.h Proc_DLC_Locator.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/09_Battery_Reset
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/09_Battery_Reset/: Proc_Battery_Reset.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/10_Oil_Reset
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/10_Oil_Reset/: Oil_Reset_V01.00.xx_Feb0315.a Proc_Oil_Reset.c
  group 1_Application/3_User_Interface/3_UI_Processes/Processes/Other_Processes
    ../1_Application/3_User_Interface/3_UI_Processes/Processes/Other_Processes/: Proc_MainMenu.c Proc_Template.c Proc_Waiting.c
  group 1_Application/3_User_Interface/4_Key_Processes
    ../1_Application/3_User_Interface/4_Key_Processes/: CommonKeyHandler.h
  group 1_Application/3_User_Interface/5_Vehicle_Data_Process
    ../1_Application/3_User_Interface/5_Vehicle_Data_Process/: Vehicle_Data_Manager.h Vehicle_Data_Structure.h
  group 1_Application/3_User_Interface/6_UI_Utilites
    ../1_Application/3_User_Interface/6_UI_Uilities/: Common_LCD_Screen.h
    ../1_Application/3_User_Interface/2_GUI_Database/1_Main_Flow/1_Text_DB/: Common_Text_Database.h
  group 2_Middle/0_Middle_Utilities
    ../2_Middle/0_Middle_Utilities/: ByteStringUtilities.h InnovaCommonEnum.h MLStringUtilities.h SystemModeFunctionUtilities.h
  group 2_Middle/0_Middle_Utilities/AES
    ../2_Middle/0_Middle_Utilities/AES/: aes256.h AseLib_Levine.a Pro_ASE_Apr022015_V01.00.01.a
  group 2_Middle/0_Middle_Utilities/System_Process_UI
    ../2_Middle/0_Middle_Utilities/System_Process_UI/: SysProcess.c SysProcess.h
  group 2_Middle/2_Vehicle_Interface/LIB
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/LIB/: DtcParser.h InnovaOBDApp.h InnovaStd.h NWSCAN_3130E_ASIC_LIB_V1.0.20.a NWSCAN_3130E_LIB_V1.0.20.a OBDIISidUtility.h PlatFormType.h SYS_Utility.h VBI_Default_App.h VBI_Utility.h VCI_App.h VDM_Adapter.h
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/MW_LIB/: NWSCAN_ADAPTER_LIB_1.0.1.a
  group 2_Middle/2_Vehicle_Interface/NWSCAN_UI/Common
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/Common/: CommonKeyHandler_Old.c CommonKeyHandler_Old.h CommonStringData.c LCDScreen.c MakesAdapterApp.h NwS_Config.h SystemData.c SystemData.h
    ../2_Middle/2_VEHICLE_INTERFACE/1_OBD_API/NWSCAN_APP/Common/: CommonStringData.h LCDScreen.h SystemUI.c SystemUI.h
    ../2_Middle/2_VEHICLE_INTERFACE/1_OBD_API/NWSCAN_APP/Adapter/Common/: VDM_Util_DBToLinkProfile.c
  group 2_Middle/2_Vehicle_Interface/NWSCAN_UI/UI
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/PROC_UI/HondaBody/: HondaBodySpecial.c
    ../2_Middle/2_VEHICLE_INTERFACE/1_OBD_API/NWSCAN_APP/PROC_UI/NwScan/: Proc_NwS_Display.c Proc_NwS_Erase.c Proc_NwS_Link.c
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/PROC_UI/FordOnDemand/: Proc_NWScan_FordEnh.c
    ../2_Middle/2_VEHICLE_INTERFACE/1_OBD_API/NWSCAN_APP/PROC_UI/System/: Proc_UI_SystemMenu.c
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/PROC_UI/System/: Proc_YMME_InFo.c
  group 2_Middle/2_Vehicle_Interface/NWSCAN_UI/UI/Ref OldTool
    ../2_Middle/2_Vehicle_Interface/1_OBD_API/NWSCAN_APP/PROC_UI/OldTool/: Proc_AvailableModules.c Proc_VehicleInfo.c Proc_ViewVehicleID.c
  group 2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver/mFTL
    ../2_Middle/3_Storage/2_Driver/3_Nand_Flash/2_Driver/mFTL/: mmlib_CortexM4.a
  group 3_Hardware_Core/1_MCU_Core
    ../3_Hardware_Core/1_MCU_Core/: coremcu.h
  group 3_Hardware_Core/1_MCU_Core/STM32F427x/Peripheral
    ../3_Hardware_Core/1_MCU_Core/STM32F427x/peripheral/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
    ../3_HARDWARE_CORE/1_MCU_CORE/STM32F427X/PERIPHERAL/src/: stm32f4xx_gpio.c
  group 3_Hardware_Core/1_MCU_Core/STM32F427x/StartUp
    ../3_HARDWARE_CORE/1_MCU_CORE/STM32F427X/startup/: startup_stm32f4xx.s stm32f4xx_it.c stm32f4xx_it.h
    ../3_Hardware_Core/1_MCU_Core/STM32F427x/startup/: stm32f4xx_flash.icf system_stm32f4xx.c
  group 4_UI_Lib
    ../4_UI_Lib/: ASIC_UI_Lib_SD.a GUI_Lib_CoreM4.a
